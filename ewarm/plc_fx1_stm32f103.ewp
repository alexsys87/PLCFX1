# IAR project plc_fx1_stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; PLC_RUNTIME_EXPERIMENTAL=1
  ICCARM.CCIncludePath2: ..\inc; ..\CMSIS; ..\CMSIS\device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: plc_fx1_stm32f103.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: bluepill_plc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F103xB; NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group App
    ../App/: main.c
  group Register drivers
    ../src/: board_clock.c plc_flash.c plc_memory.c plc_io.c plc_rtc.c
  group Programming link
    ../src/: plc_serial_protocol.c
  group Runtime minimal
    ../src/: plc_runtime_minimal.c
  group Runtime experimental
    ../src/: plc_exp_arithmetic.c plc_exp_compare_contacts.c plc_exp_compare_move.c plc_exp_data.c plc_exp_dispatch.c plc_exp_float.c plc_exp_flow.c plc_exp_logic.c plc_exp_operands.c plc_exp_rotate_shift.c plc_exp_scan.c plc_exp_time.c plc_exp_timers.c plc_exp_unsupported.c
  group ST
    ../CMSIS/device/: startup_stm32f103xb.s system_stm32f1xx.c
